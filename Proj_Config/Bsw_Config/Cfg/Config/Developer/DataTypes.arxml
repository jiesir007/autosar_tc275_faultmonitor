AUTOSAR XML (schema 00046)
standard types defined: boolean, uint16, uint32, uint8
package /Predefined_DEV/ImplementationDataTypes
  impl type NvM_RequestResultType: compu {0=NVM_REQ_OK, 1=NVM_REQ_NOT_OK, 2=NVM_REQ_PENDING, 3=NVM_REQ_INTEGRITY_FAILED, 4=NVM_REQ_BLOCK_SKIPPED, 5=NVM_REQ_NV_INVALIDATED, 6=NVM_REQ_CANCELED, 7=NVM_REQ_REDUNDANCY_FAILED, 8=NVM_REQ_RESTORED_FROM_ROM}, implementation-data-type=uint8
  impl type NvM_ServiceIdType: compu {6=NVM_READ_BLOCK, 7=NVM_WRITE_BLOCK, 8=NVM_RESTORE_BLOCK_DEFAULTS, 9=NVM_ERASE_BLOCK, 11=NVM_INVALIDATE_NV_BLOCK, 12=NVM_READ_ALL}, implementation-data-type=uint8
  impl type Dem_UdsStatusByteType: compu {mask 1: 1=DEM_UDS_STATUS_TF, mask 2: 2=DEM_UDS_STATUS_TFTOC, mask 4: 4=DEM_UDS_STATUS_PDTC, mask 8: 8=DEM_UDS_STATUS_CDTC, mask 16: 16=DEM_UDS_STATUS_TNCSLC, mask 32: 32=DEM_UDS_STATUS_TFSLC, mask 64: 64=DEM_UDS_STATUS_TNCTOC, mask 128: 128=DEM_UDS_STATUS_WIR}, range raw 0..255, implementation-data-type=uint8
package /DataType
  base type uint8_8_iso_8859_1: category=FIXED_LENGTH, base-type-size=64, base-type-encoding=ISO-8859-1
package /DataType/Constraint
  range DC_BMS_AccueChrgTotAh: raw 0..4294967295
  range DC_BMS_AccueDchaTotAh: raw 0..4294967295
  range DC_BMS_CellCHargerMaxVolt: raw 0..5000
  range DC_BMS_DCChrgRmngTi: raw 0..65535
  range DC_BMS_DrvgMilg: raw 0..2000
  range DC_BMS_FAULT_CODE{1..3}: raw 0..255
  range DC_BMS_HeatRemainingTime: raw 0..65535
  range DC_BMS_HwVers: raw 0..255
  range DC_BMS_INSULATION_R: raw 0..65534
  range DC_BMS_INSULATION_R_NEG: raw 0..65534
  range DC_BMS_INSULATION_R_POS: raw 0..65534
  range DC_BMS_MaxCellVoltCod: raw 0..255
  range DC_BMS_MaxTCod: raw 0..255
  range DC_BMS_MinCellVoltCod: raw 0..255
  range DC_BMS_MinTCod: raw 0..255
  range DC_BMS_PwrBattCellSum: raw 0..255
  range DC_BMS_PwrBattCellTSum: raw 0..255
  range DC_BMS_PwrBattPackCod{1..4}: raw 0..16777215
  range DC_BMS_PwrBattPackCodLen: raw 0..255
  range DC_BMS_PwrBattPackNr: raw 0..255
  range DC_BMS_PwrBattPackPrllNr: raw 0..255
  range DC_BMS_PwrBattPackSerlNr: raw 0..255
  range DC_BMS_PwrBattSubsysNr: raw 0..255
  range DC_BMS_SwVers: raw 0..255
  range DC_BMS_TotalFault: raw 0..255
  range DC_Checksum_110: raw 0..255
  range DC_Checksum_132: raw 0..255
  range DC_Checksum_1E3: raw 0..255
  range DC_Checksum_300: raw 0..255
  range DC_Checksum_303: raw 0..255
  range DC_Checksum_3A0: raw 0..255
  range DC_Checksum_90: raw 0..255
  range DC_Checksum_94: raw 0..255
  range DC_Checksum_98: raw 0..255
  range DC_Checksum0x162: raw 0..255
  range DC_Checksum0x182: raw 0..255
  range DC_Checksum0x192: raw 0..255
  range DC_Checksum0x201: raw 0..255
  range DC_Checksum0x310: raw 0..255
  range DC_Checksum0x313: raw 0..255
  range DC_Checksum0x92: raw 0..255
  range DC_Checksum152: raw 0..255
  range DC_Checksum30B: raw 0..255
  range DC_Checksum30F: raw 0..255
  range DC_DCDC_CAL_VERS: raw 0..255
  range DC_DCDC_HW_Version: raw 0..255
  range DC_DCDC_PART_VERS: raw 0..4294967295
  range DC_DCDC_SW_VERS: raw 0..255
  range DC_EPS_HwVers: raw 0..255
  range DC_EPS_PartVers: raw 0..4294967295
  range DC_EPS_SwVersM: raw 0..255
  range DC_EPS_SwVersS: raw 0..255
  range DC_GBT_CCS_iOutput: raw 0..65535
  range DC_IKEY_VIN_Byte_1: raw 0..255
  range DC_IKEY_VIN_Byte_{10..17}: raw 0..255
  range DC_IKEY_VIN_Byte_{2..9}: raw 0..255
  range DC_IPB_WheelOdoPulse_FL: raw 0..65535
  range DC_IPB_WheelOdoPulse_FR: raw 0..65535
  range DC_IPB_WheelOdoPulse_RL: raw 0..65535
  range DC_IPB_WheelOdoPulse_RR: raw 0..65535
  range DC_IVI_Time_Day: raw 1..31
  range DC_IVI_Time_Hour: raw 0..23
  range DC_IVI_Time_Min: raw 0..59
  range DC_IVI_Time_Month: raw 1..12
  range DC_IVI_Time_Sec: raw 0..59
  range DC_MCU_AllowInputTrq_Min: raw 0..255
  range DC_MCU_bus_Volt: raw 0..2047
  range DC_MCU_CAL_SW_VER: raw 0..31
  range DC_MCU_CAL_VERS: raw 0..255
  range DC_MCU_HW_VERS: raw 0..255
  range DC_MCU_MCU_F_SUM: raw 0..255
  range DC_MCU_MCU_SUPPLIER: raw 0..15
  range DC_MCU_MOT_CODE1: raw 0..16777215
  range DC_MCU_Motor_NUM: raw 0..255
  range DC_MCU_Motor_SUM: raw 0..255
  range DC_MCU_PART_VERS: raw 0..4294967295
  range DC_MCU_SW_VERS: raw 0..255
  range DC_NMUd_IVI_16bit: raw 0..65535
  range DC_NMUd_IVI_32bit: raw 0..4294967295
  range DC_RollingCounte0x313: raw 0..15
  range DC_RollingCounter_110: raw 0..15
  range DC_RollingCounter_132: raw 0..15
  range DC_RollingCounter_1E3: raw 0..15
  range DC_RollingCounter_300: raw 0..15
  range DC_RollingCounter_303: raw 0..15
  range DC_RollingCounter_3A0: raw 0..15
  range DC_RollingCounter_90: raw 0..15
  range DC_RollingCounter_94: raw 0..15
  range DC_RollingCounter_98: raw 0..15
  range DC_RollingCounter0x162: raw 0..15
  range DC_RollingCounter0x182: raw 0..15
  range DC_RollingCounter0x192: raw 0..15
  range DC_RollingCounter0x201: raw 0..15
  range DC_RollingCounter0x310: raw 0..15
  range DC_RollingCounter0x92: raw 0..15
  range DC_RollingCounter152: raw 0..15
  range DC_RollingCounter30B: raw 0..15
  range DC_RollingCounter30F: raw 0..15
  range DC_VCU_AccPedalPosition: raw 0..100
  range DC_VCU_CalVersS: raw 0..255
  range DC_VCU_DrvgMilg: raw 0..2000
  range DC_VCU_HwVers: raw 0..255
  range DC_VCU_PartVers: raw 0..4294967295
  range DC_VCU_SwVers: raw 0..255
  range DC_VCU_SwVersM: raw 0..255
  range DC_VCU_WaterPumpDutyCycle: raw 0..100
  range DC_PowerMode: raw 0..7
  range DC_Sig_0x114_Used_1: raw 0..15
  range DC_Sig_0x114_Used_2: raw 0..4095
  range DC_Sig_0x114_Used_3: raw 0..65535
  range DC_Sig_0x114_Used_4: raw 0..65535
  range DC_Sig_0x114_Used_5: raw 0..255
  range DC_Sig_0x402_Used_1: raw 0..15
  range DC_Sig_0x402_Used_2: raw 0..4095
  range DC_Sig_0x402_Used_{3..5}: raw 0..65535
  range DC_Sig_0x403_Used_1: raw 0..15
  range DC_Sig_0x403_Used_2: raw 0..4095
  range DC_Sig_0x403_Used_{3..5}: raw 0..65535
  range DC_SupA_Checksum_0x112: raw 0..255
  range DC_SupA_Counter_0x112: raw 0..14
  range DC_Sig_0x114_Used_6: raw 0..255
  range DC_E_Sig_0x302_Used_1: raw 0..65535
  range DC_E_Sig_0x302_Used_2: raw 0..255
  range DC_E_Sig_0x302_Used_3: raw 0..255
  range DC_F_Button{1..4}_State: raw 0..7
  range DC_F_Meg_E2E_Error: raw 0..255
  range DC_F_Mes_Lost_Error: raw 0..255
  range DC_F_PowerMode: raw 0..7
  range DC_F_Sig_0x214_Used_{1..3}: raw 0..65535
  range DC_F_Sig_0x214_Used_5: raw 0..65535
  range DC_SupD_Checksum_0x300: raw 0..255
  range DC_SupD_Checksum_0x304: raw 0..255
  range DC_SupD_Counter_0x300: raw 0..14
  range DC_SupD_Counter_0x304: raw 0..14
  range DC_SupF_Checksum_0x212: raw 0..255
  range DC_SupF_Counter_0x212: raw 0..14
package /DataType/Semantics
  compu method CM_AC_3BDC_RespPos: phys=raw*0.392 for raw 0..651
  compu method CM_AC_4BDC_RespPos1: 0=Cx0_Open_Port_1_to_Port_2_Port_3_to_port_4 (Open Port 1 to Port 2, Port 3 to port 4), 1=Cx1_Open_Port_1_to_Port_4_Port_2_to_port_3 (Open Port 1 to Port 4, Port 2 to port 3), 2=Cx2_Valve_is_closing (Valve is closing), 3=Cx3_Valve_is_opening (Valve is opening)
  compu method CM_AC_4BDC_RespPos2: 0=Cx0_Open_Port_1_to_Port_2_Port_3_to_port_4 (Open Port 1 to Port 2, Port 3 to port 4), 1=Cx1_Open_Port_1_to_Port_4_Port_2_to_port_3 (Open Port 1 to Port 4, Port 2 to port 3), 2=Cx2_Valve_is_closing (Valve is closing), 3=Cx3_Valve_is_opening (Valve is opening)
  compu method CM_AC_ACWorkSts: 0=Cx0_Off, 1=Cx1_A_C_On (A/C On), 2=Cx2_Reversed, 3=Cx3_Reversed
  compu method CM_AC_BTHFP_AutoAirVOL_SWSts: 0=Cx0_ (未开启), 1=Cx1_ (开启)
  compu method CM_AC_CycleStatus: 0=Cx0_Outside_Cycle (Outside Cycle), 1=Cx1_Inside_Cycle (Inside Cycle)
  compu method CM_AC_ECOMSts: 0=Cx0_ (舒适), 1=Cx1_ (经济)
  compu method CM_AC_FastCoolingSts: 0=Cx0_ (未开启), 1=Cx1_ (开启)
  compu method CM_AC_FLFanGear: 0=Cx0_Off, 1=Cx1_Gear_1 (Gear 1), 2=Cx2_Gear_2 (Gear 2), 3=Cx3_Gear_3 (Gear 3), 4=Cx4_Gear_4 (Gear 4), 5=Cx5_Gear_5 (Gear 5), 6=Cx6_Gear_6 (Gear 6), 7=Cx7_Gear_7 (Gear 7), 8=Cx8_Reversed, 9=Cx9_Reversed, 10=CxA_Reversed, 11=CxB_Reversed, 12=CxC_Reversed, 13=CxD_Reversed, 14=CxE_Reversed, 15=CxF_INVALID
  compu method CM_AC_FrontDefrostSts: 0=Cx0_Off, 1=Cx1_On
  compu method CM_AC_InsideTemp: phys=raw*0.5-40 for raw 0..240
  compu method CM_AC_IntelligenTaerationSts: 0=Cx0_ (未开启), 1=Cx1_ (开启)
  compu method CM_AC_ModelDisplay: 0=Cx0_Face, 1=Cx1_Face_and_Foot (Face and Foot), 2=Cx2_Foot, 3=Cx3_Foot_and_defrost (Foot and defrost), 4=Cx4_Window, 5=Cx5_Reserved, 6=Cx6_Reserved, 7=Cx7_INVALID
  compu method CM_AC_ModeSts: 0=Cx0_Off, 1=Cx1_On
  compu method CM_AC_OutsideTemp: phys=raw*0.5-40 for raw 0..240
  compu method CM_AC_OutsideTempVD: 0=Cx0_INVALID, 1=Cx1_VALID
  compu method CM_AC_SetTemp: 0=Cx00_INVALID, 1=Cx01_17_ (17℃), 2=Cx02_18_ (18℃), 3=Cx03_19_ (19℃), 4=Cx04_20_ (20℃), 5=Cx05_21_ (21℃), 6=Cx06_22_ (22℃), 7=Cx07_23_ (23℃), 8=Cx08_24_ (24℃), 9=Cx09_25_ (25℃), 10=Cx0A_26_ (26℃), 11=Cx0B_27_ (27℃), 12=Cx0C_28_ (28℃), 13=Cx0D_29_ (29℃), 14=Cx0E_30_ (30℃), 15=Cx0F_31_ (31℃), 16=Cx10_32_ (32℃), 17=Cx11_33_ (33℃), 18=Cx12_Reserved, 19=Cx13_Reserved, 20=Cx14_Reserved, 21=Cx15_Reserved, 22=Cx16_Reserved, 23=Cx17_Reserved, 24=Cx18_Reserved, 25=Cx19_Reserved, 26=Cx1A_Reserved, 27=Cx1B_Reserved, 28=Cx1C_Reserved, 29=Cx1D_Reserved, 30=Cx1E_Reserved, 31=Cx1F_Reserved
  compu method CM_AC_SolenoidValveSta: 0=Cx0_Not_Active (Not Active), 1=Cx1_Active
  compu method CM_AC_WorkSts: 0=Cx0_Manual, 1=Cx1_Auto
  compu method CM_ACU_AirBagFailSt: 0=Cx0_Fail_no_present_Lamp_off (Fail no present, Lamp off), 1=Cx1_Fail_no_present_Lamp_flashing (Fail no present,Lamp flashing), 2=Cx2_Fail_present_Lamp_on_Startup_Default_ (Fail present, Lamp on(Startup/Default)), 3=Cx3_Not_Used (Not Used)
  compu method CM_ACU_CrashOutputSt: 0=Cx0_No_crash (No crash), 1=Cx1_crash
  compu method CM_ACU_DrvSeatBeltRSt: 0=Cx0_Safety_belt_tied_Switch_off_ (Safety belt tied(Switch off )), 1=Cx1_Safety_belt_not_tied_Switch_on_ (Safety belt not tied(Switch on))
  compu method CM_ACU_PsSeaOccupantSensorSts: 0=Cx0_Empty, 1=Cx1_Occupied
  compu method CM_ACU_PsSeatBeltRSt: 0=Cx0_Safety_belt_tied_Switch_off_ (Safety belt tied(Switch off )), 1=Cx1_Safety_belt_not_tied_Switch_on_ (Safety belt not tied(Switch on))
  compu method CM_BMS_AccueChrgTotAh: identical
  compu method CM_BMS_AccueDchaTotAh: identical
  compu method CM_BMS_BAT_SOC_LOW_IND: 0=Cx0_NotActive, 1=Cx1_Active
  compu method CM_BMS_BattAvrgT: phys=raw-48 for raw 0..255
  compu method CM_BMS_BattBalActv: 0=Cx0_Normal_Sampling (Normal Sampling), 1=Cx1_Charging_Balance (Charging Balance), 2=Cx2_Discharging_Balance (Discharging Balance), 3=Cx3_Fault
  compu method CM_BMS_BatTempDiff_Anomaly: 0=Cx0_ (正常), 1=Cx1_ (故障)
  compu method CM_BMS_BattInlTDmd: phys=raw-48 for raw 0..255
  compu method CM_BMS_CellCHargerMaxVolt: identical
  compu method CM_BMS_CellDiffT: phys=raw-48 for raw 0..255
  compu method CM_BMS_CellMaxT: phys=raw-48 for raw 0..255
  compu method CM_BMS_CellMinT: phys=raw-48 for raw 0..255
  compu method CM_BMS_CellT{1..8}: phys=raw-48 for raw 0..255
  compu method CM_BMS_CellTemp_SerOver: 0=Cx0_ (正常), 1=Cx1_ (故障)
  compu method CM_BMS_CellUniformity_Fault: 0=Cx0_ (正常), 1=Cx1_ (故障)
  compu method CM_BMS_CellVolt_LimitOver: 0=Cx0_ (正常), 1=Cx1_ (故障)
  compu method CM_BMS_CellVolt_LimitUder: 0=Cx0_ (正常), 1=Cx1_ (故障)
  compu method CM_BMS_DCChrgCrtOver: 0=Cx0_ (正常), 1=Cx1_ (电流过大), 2=Cx2_ (不可信), 3=Cx3_Reserved
  compu method CM_BMS_DCChrgRmngTi: identical
  compu method CM_BMS_DCChrgVoltFlt: 0=Cx0_ (正常), 1=Cx1_ (电压异常), 2=Cx2_ (不可信), 3=Cx3_Reserved
  compu method CM_BMS_DrvgMilg: identical
  compu method CM_BMS_DrvgMilg_Valid: 0=Cx0_INVALID, 1=Cx1_VALID
  compu method CM_BMS_FAULT_CODE{1..3}: identical
  compu method CM_BMS_HeatRemainingTime: identical
  compu method CM_BMS_HV_PRE_CHARGE_REL_STS: 0=Cx0_Open, 1=Cx1_Closed, 2=Cx2_Error, 3=Cx3_Reserved
  compu method CM_BMS_HwVers: identical
  compu method CM_BMS_INSULATION_FAULT: 0=Cx0_OK_500_V (OK ＞500Ω/V), 1=Cx1_Error_Lv1_100_500_V (Error Lv1 100~500Ω/V), 2=Cx2_Error_Lv2_100_V (Error Lv2 <100Ω/V), 3=Cx3_Invalid
  compu method CM_BMS_INSULATION_R: identical
  compu method CM_BMS_INSULATION_R_NEG: identical
  compu method CM_BMS_INSULATION_R_POS: identical
  compu method CM_BMS_MaxCellVoltCod: identical
  compu method CM_BMS_MaxTCod: identical
  compu method CM_BMS_MinCellVoltCod: identical
  compu method CM_BMS_MinTCod: identical
  compu method CM_BMS_MODE: 0=Cx0_Init_ (Init 初始化), 1=Cx1_Standby_ (Standby 待机), 2=Cx2_PreCharge_ae (PreCharge预充), 3=Cx3_Operational_ (Operational 放电), 4=Cx4_Charge_ae_ (Charge 充电), 5=Cx5_Powerdown_Oe_ (Powerdown 下电中), 6=Cx6_Charge_Prepare_ae_ (Charge_Prepare 充电准备), 7=Cx7_Sleep_ss (Sleep 休眠), 8=Cx8_Service_Ae_ (Service 服务模式), 9=Cx9_Emergency_Discharge (Emergency Discharge), 10=CxA_Fault_State_ (Fault_State 故障状态), 11=CxB_Complete_Powerdown_ (Complete Powerdown下电完成), 12=CxC_Reserved, 13=CxD_Reserved, 14=CxE_Reserved, 15=CxF_Reserved
  compu method CM_BMS_NEG_RELAY_WELD_STS: 0=Cx0_No_Welded (No Welded), 1=Cx1_Welded
  compu method CM_BMS_OtherFlt: 0=Cx0_ (正常), 1=Cx1_ (故障), 2=Cx2_ (不可信), 3=Cx3_Reserved
  compu method CM_BMS_POS_RELAY_WELD_STS: 0=Cx0_No_Welded (No Welded), 1=Cx1_Welded
  compu method CM_BMS_PweBattPackAllowTepm: phys=raw-48 for raw 0..255
  compu method CM_BMS_PwrBattCellSum: identical
  compu method CM_BMS_PwrBattCellTSum: identical
  compu method CM_BMS_PwrBattHeatgMngDmd: 0=Cx0_ (无需求), 1=Cx1_ (加热一档需求), 2=Cx2_ (加热二挡需求), 3=Cx3_ (加热三挡需求), 4=Cx4_Oe_ae_ (制冷一档需求), 5=Cx5_Oe_ae_ (制冷二挡需求), 6=Cx6_Oe_ae_ (制冷三挡需求), 7=Cx7_ (无循环), 8=Cx8_Reserved, 9=Cx9_Reserved, 10=CxA_Reserved, 11=CxB_Reserved, 12=CxC_Reserved, 13=CxD_Reserved, 14=CxE_Reserved, 15=CxF_Reserved
  compu method CM_BMS_PwrBattOverChrgAlrm: 0=Cx0_ (无故障), 1=Cx1_ (有故障)
  compu method CM_BMS_PwrBattPackCod{1..4}: identical
  compu method CM_BMS_PwrBattPackCodLen: identical
  compu method CM_BMS_PwrBattPackNr: identical
  compu method CM_BMS_PwrBattPackPrllNr: identical
  compu method CM_BMS_PwrBattPackSerlNr: identical
  compu method CM_BMS_PwrBattSubsysNr: identical
  compu method CM_BMS_PwrBattSysFltDisp: 0=Cx0_ (正常), 1=Cx1_ (异常)
  compu method CM_BMS_PwrBattTyp: 0=Cx0_ae_ (其他), 1=Cx1_Ae_ (镍氢电池), 2=Cx2_ (磷酸铁锂电池), 3=Cx3_ (锰酸锂电池), 4=Cx4_ (锂硫电池), 5=Cx5_Ae_ (三元材料电池), 6=Cx6_Ae_ (钠硫电池), 7=Cx7_ (钛酸锂电池), 8=Cx8_ (铅酸电池), 9=Cx9_ (金属空气电池), 10=CxA_Reserved, 11=CxB_Reserved, 12=CxC_Reserved, 13=CxD_Reserved, 14=CxE_Reserved, 15=CxF_Reserved
  compu method CM_BMS_REESS_SysNoMatch: 0=Cx0_ (正常), 1=Cx1_ (故障)
  compu method CM_BMS_SOC_Jump: 0=Cx0_ (正常), 1=Cx1_ (故障)
  compu method CM_BMS_SOC_Over: 0=Cx0_ (正常), 1=Cx1_ (故障)
  compu method CM_BMS_SOC_Under: 0=Cx0_ (正常), 1=Cx1_ (故障)
  compu method CM_BMS_SwVers: identical
  compu method CM_BMS_TotalFault: identical
  compu method CM_BMS_TotVoltOver: 0=Cx0_ (正常), 1=Cx1_ (故障)
  compu method CM_BMS_TotVoltUder: 0=Cx0_ (正常), 1=Cx1_ (故障)
  compu method CM_BMS_VehInsulFltDisp: 0=Cx0_ (正常), 1=Cx1_ (异常)
  compu method CM_Checksum_110: identical
  compu method CM_Checksum_132: identical
  compu method CM_Checksum_1E3: identical
  compu method CM_Checksum_300: identical
  compu method CM_Checksum_303: identical
  compu method CM_Checksum_3A0: identical
  compu method CM_Checksum_90: identical
  compu method CM_Checksum_94: identical
  compu method CM_Checksum_98: identical
  compu method CM_Checksum0x162: identical
  compu method CM_Checksum0x182: identical
  compu method CM_Checksum0x192: identical
  compu method CM_Checksum0x201: identical
  compu method CM_Checksum0x310: identical
  compu method CM_Checksum0x313: identical
  compu method CM_Checksum0x92: identical
  compu method CM_Checksum152: identical
  compu method CM_Checksum30B: identical
  compu method CM_Checksum30F: identical
  compu method CM_DCDC_CAL_VERS: identical
  compu method CM_DCDC_FAULT_TYPE: 0=Cx0_No_error (No error), 1=Cx1_Warning, 2=Cx2_Recoverable_fault (Recoverable fault), 3=Cx3_Unrecoverable_fault (Unrecoverable fault)
  compu method CM_DCDC_HW_Version: identical
  compu method CM_DCDC_OverTFlt: 0=Cx0_Normal, 1=Cx1_Fault
  compu method CM_DCDC_PART_VERS: identical
  compu method CM_DCDC_STATE: 0=Cx0_ (初始化), 1=Cx1_ (待机), 2=Cx2_ (工作), 3=Cx3_ (故障), 4=Cx4_ (下电), 5=Cx5_ (降功率), 6=Cx6_Reserved, 7=Cx7_Invalid
  compu method CM_DCDC_SW_VERS: identical
  compu method CM_EAS_WorkingStatus: 0=Cx0_ (待机), 1=Cx1_ (正常工作), 2=Cx2_Oe_ (限制工作), 3=Cx3_ (故障停机)
  compu method CM_EPB_Sts: 0=Cx0_releasing_Oe_ (releasing (释放过程中)), 1=Cx1_Released_ (Released (释放完成)), 2=Cx2_applying, 3=Cx3_Applied, 4=Cx4_Fault, 5=Cx5_Over_Released (Over-Released), 6=Cx6_NotInitialized, 7=Cx7_Reserved
  compu method CM_EPB_SwitchSts: 0=Cx0_NotActive_Oe_ (NotActive(中立,未操作)), 1=Cx1_Release_ (Release(按下释放)), 2=Cx2_Apply_ (Apply(拉起夹紧)), 3=Cx3_Reserved
  compu method CM_EPB_SwitchStsValid: 0=Cx0_Valid, 1=Cx1_Not_valid (Not valid)
  compu method CM_EPB_SysWarningIndicationReq: 0=Cx0_No_Indication (No Indication), 1=Cx1_Continuous_Indication (Continuous Indication), 2=Cx2_Flash_Rate_1_Indication (Flash Rate #1 Indication), 3=Cx3_Flash_Rate_2_Indication (Flash Rate #2 Indication)
  compu method CM_EPS_AnglEndProtectunlearn: 0=Cx0_ (正常), 1=Cx1_ (故障)
  compu method CM_EPS_AnglSensorCalibrated: 0=Cx0_ (正常), 1=Cx1_ (故障)
  compu method CM_EPS_AnglSensorComparefailure: 0=Cx0_ (正常), 1=Cx1_ (故障)
  compu method CM_EPS_AnglSensorPSignalImplausible: 0=Cx0_ (正常), 1=Cx1_ (故障)
  compu method CM_EPS_AnglSensorSSignalImplausible: 0=Cx0_ (正常), 1=Cx1_ (故障)
  compu method CM_EPS_BATT_LOW_VOLT_ERR: 0=Cx0_ (正常), 1=Cx1_ (故障)
  compu method CM_EPS_BATT_OVER_VOLT_ERR: 0=Cx0_ (正常), 1=Cx1_ (故障)
  compu method CM_EPS_BDMSignalIsunavailable: 0=Cx0_ (正常), 1=Cx1_ (故障)
  compu method CM_EPS_CANBusOFF: 0=Cx0_ (正常), 1=Cx1_ (故障)
  compu method CM_EPS_CrtSts: 0=Cx0_ (正常工作状态), 1=Cx1_ (故障状态)
  compu method CM_EPS_DutyCycleT1T2: 0=Cx0_ (正常), 1=Cx1_ (故障)
  compu method CM_EPS_DutyCycleTasT1: 0=Cx0_ (正常), 1=Cx1_ (故障)
  compu method CM_EPS_DutyCycleTasT2: 0=Cx0_ (正常), 1=Cx1_ (故障)
  compu method CM_EPS_ECU_RAMFault: 0=Cx0_ (正常), 1=Cx1_ (故障)
  compu method CM_EPS_ECU_ROMFault: 0=Cx0_ (正常), 1=Cx1_ (故障)
  compu method CM_EPS_ECUCurrentError: 0=Cx0_ (正常), 1=Cx1_ (故障)
  compu method CM_EPS_ECUFlashError: 0=Cx0_ (正常), 1=Cx1_ (故障)
  compu method CM_EPS_ECUOverTemperature: 0=Cx0_ (正常), 1=Cx1_ (故障)
  compu method CM_EPS_ECUTempSensorErr: 0=Cx0_ (正常), 1=Cx1_ (故障)
  compu method CM_EPS_ElecFailureInECU: 0=Cx0_ (正常), 1=Cx1_ (故障)
  compu method CM_EPS_ESCSignalIsunavailable: 0=Cx0_ (正常), 1=Cx1_ (故障)
  compu method CM_EPS_GateDriverFault: 0=Cx0_ (正常), 1=Cx1_ (故障)
  compu method CM_EPS_HwVers: identical
  compu method CM_EPS_ICMSignalIsunavailable: 0=Cx0_ (正常), 1=Cx1_ (故障)
  compu method CM_EPS_IG_TheIgKL: 0=Cx0_ (正常), 1=Cx1_ (故障)
  compu method CM_EPS_InitSelfCheck: 0=Cx0_ (正常), 1=Cx1_ (故障)
  compu method CM_EPS_IVISignalIsunavailable: 0=Cx0_ (正常), 1=Cx1_ (故障)
  compu method CM_EPS_LosCommunicationWithESC: 0=Cx0_ (正常), 1=Cx1_ (故障)
  compu method CM_EPS_LostCommunicationVcu: 0=Cx0_ (正常), 1=Cx1_ (故障)
  compu method CM_EPS_LostCommunicationWithBDM: 0=Cx0_ (正常), 1=Cx1_ (故障)
  compu method CM_EPS_LostCommunicationWithICM: 0=Cx0_ (正常), 1=Cx1_ (故障)
  compu method CM_EPS_LostCommunicationWithIVI: 0=Cx0_ (正常), 1=Cx1_ (故障)
  compu method CM_EPS_MCU_ExternalFailure: 0=Cx0_ (正常), 1=Cx1_ (故障)
  compu method CM_EPS_MCU_InitResetFailure: 0=Cx0_ (正常), 1=Cx1_ (故障)
  compu method CM_EPS_MCU_InternalError: 0=Cx0_ (正常), 1=Cx1_ (故障)
  compu method CM_EPS_ModeChangeEnable: 0=Cx0_Disable, 1=Cx1_Enable
  compu method CM_EPS_MotoPhaseOpen: 0=Cx0_ (正常), 1=Cx1_ (故障)
  compu method CM_EPS_MotoRotorPositionFault: 0=Cx0_ (正常), 1=Cx1_ (故障)
  compu method CM_EPS_MotoTerminalVoltageabnormality: 0=Cx0_ (正常), 1=Cx1_ (故障)
  compu method CM_EPS_MotoThreePhaseAbnormality: 0=Cx0_ (正常), 1=Cx1_ (故障)
  compu method CM_EPS_MotoThreePhaseFailure: 0=Cx0_ (正常), 1=Cx1_ (故障)
  compu method CM_EPS_MotroControlError: 0=Cx0_ (正常), 1=Cx1_ (故障)
  compu method CM_EPS_PartVers: identical
  compu method CM_EPS_PeriOfTasT1: 0=Cx0_ (正常), 1=Cx1_ (故障)
  compu method CM_EPS_PeriOfTasT2: 0=Cx0_ (正常), 1=Cx1_ (故障)
  compu method CM_EPS_PowerCircuitError: 0=Cx0_ (正常), 1=Cx1_ (故障)
  compu method CM_EPS_PoweSupplyAbnormality: 0=Cx0_ (正常), 1=Cx1_ (故障)
  compu method CM_EPS_ReduOfOverheat: 0=Cx0_ (正常), 1=Cx1_ (故障)
  compu method CM_EPS_SteerPrsnlMod: 0=Cx0_Reserved, 1=Cx1_Ae_ (舒适模式), 2=Cx2_Ae_ (标准模式), 3=Cx3_Reserved
  compu method CM_EPS_SwitPowerFault: 0=Cx0_ (正常), 1=Cx1_ (故障)
  compu method CM_EPS_SwVersM: identical
  compu method CM_EPS_SwVersS: identical
  compu method CM_EPS_TorqSensorTiemOutT1T2: 0=Cx0_ (正常), 1=Cx1_ (故障)
  compu method CM_EPS_VCUSignalUnavailable: 0=Cx0_ (正常), 1=Cx1_ (故障)
  compu method CM_GBT_CCS_iOutput: identical
  compu method CM_GBT_CST_ConnectError: 0=Cx0_Normal, 1=Cx1_ConnectError, 2=Cx2_Invaild, 3=Cx3_Reserved
  compu method CM_GBT_CST_CurrentMismatch: 0=Cx0_Normal, 1=Cx1_CurrentMismatch, 2=Cx2_Invaild, 3=Cx3_Reserved
  compu method CM_GBT_CST_EmergencyErrir: 0=Cx0_Normal, 1=Cx1_EmergencyError, 2=Cx2_Invaild, 3=Cx3_Reserved
  compu method CM_GBT_CST_InsideOverTemp: 0=Cx0_Normal, 1=Cx1_InsideOverTemp, 2=Cx2_Invaild, 3=Cx3_Reserved
  compu method CM_GBT_CST_OverTemp: 0=Cx0_Normal, 1=Cx1_OverTemp, 2=Cx2_Invaild, 3=Cx3_Reserved
  compu method CM_GBT_CST_PowerTransfer: 0=Cx0_Normal, 1=Cx1_NotTransfer, 2=Cx2_Invaild, 3=Cx3_Reserved
  compu method CM_GBT_CST_StopBMS: 0=Cx0_Normal, 1=Cx1_ReceiveBST, 2=Cx2_Invaild, 3=Cx3_Reserved
  compu method CM_GBT_CST_StopError: 0=Cx0_Normal, 1=Cx1_StopError, 2=Cx2_Invaild, 3=Cx3_Reserved
  compu method CM_GBT_CST_StopManual: 0=Cx0_Normal, 1=Cx1_StopManual, 2=Cx2_Invaild, 3=Cx3_Reserved
  compu method CM_GBT_CST_StopOtherError: 0=Cx0_Normal, 1=Cx1_StopOtherError, 2=Cx2_Invaild, 3=Cx3_Reserved
  compu method CM_GBT_CST_VoltAbnormal: 0=Cx0_Normal, 1=Cx1_VoltAbnormal, 2=Cx2_Invaild, 3=Cx3_Reserved
  compu method CM_GSM_Fault_Info: 0=Cx0_ (无故障), 1=Cx1_ (轻微故障), 2=Cx2_Oe_ (严重故障), 3=Cx3_Reserved
  compu method CM_GSM_faultSts: 0=Cx0_NORMAL, 1=Cx1_FAULT
  compu method CM_GSM_gearSelectorPos: 0=Cx0_initial_position (initial position), 1=Cx1_L1_position (L1 position), 2=Cx2_L2_position (L2 position), 3=Cx3_R1_position (R1 position), 4=Cx4_R2_position (R2 position), 5=Cx5_Reserved, 6=Cx6_Reserved, 7=Cx7_Reserved
  compu method CM_IKEY_VIN_Byte_1: identical
  compu method CM_IKEY_VIN_Byte_{10..17}: identical
  compu method CM_IKEY_VIN_Byte_{2..9}: identical
  compu method CM_IKEY_Vrify_Motr_Data_Rslt_S: 0=Cx0_INVALID, 1=Cx1_VCU_Oe_Ue (VCU数据验证失败), 2=Cx2_VCU_Oe_ (VCU数据验证成功), 3=Cx3_Reserved
  compu method CM_IPB_ABS_Fault: 0=Cx0_Normal, 1=Cx1_Fault
  compu method CM_IPB_AVH_Fault: 0=Cx0_Normal, 1=Cx1_Fault
  compu method CM_IPB_AVHSts: 0=Cx0_Off, 1=Cx1_Standby, 2=Cx2_Active, 3=Cx3_Reserved
  compu method CM_IPB_BrakeFluid_Warning: 0=Cx0_BrakeFluid_Normal_Init_Default (BrakeFluid_Normal/Init/Default), 1=Cx1_BrakeFluid_Empty, 2=Cx2_BrakeFluid_Electric_error, 3=Cx3_Reserved
  compu method CM_IPB_EBD_Fault: 0=Cx0_Normal, 1=Cx1_Fault
  compu method CM_IPB_EPBParkRequest: 0=Cx0_No_Request (No Request), 1=Cx1_Release_brake_request (Release brake request), 2=Cx2_Lock_brake_request (Lock brake request), 3=Cx3_Reserved
  compu method CM_IPB_ESP_Active: 0=Cx0_Not_active (Not active), 1=Cx1_Active
  compu method CM_IPB_ESP_Fault: 0=Cx0_Normal, 1=Cx1_Fault
  compu method CM_IPB_ESPOFF_SwitchStatus: 0=Cx0_Off_ESP_OFFOe_ (Off（ESP OFF指示灯熄灭)), 1=Cx1_On_ESP_OFFOe_ (On（ESP OFF指示灯点亮))
  compu method CM_IPB_HDC_Available: 0=Cx0_Not_available (Not available), 1=Cx1_Available
  compu method CM_IPB_HDC_Status: 0=Cx0_Off, 1=Cx1_Standby, 2=Cx2_Active, 3=Cx3_Reserved
  compu method CM_IPB_HHC_Available: 0=Cx0_Not_available (Not available), 1=Cx1_Available
  compu method CM_IPB_InputRodStroke_Status: 0=Cx0_Valid, 1=Cx1_Not_valid (Not valid)
  compu method CM_IPB_Itpms_WarningDis: 0=Cx0_No_Tire_Pressure_Warning (No Tire Pressure Warning), 1=Cx1_Tire_Pressure_Warning (Tire Pressure Warning)
  compu method CM_IPB_ItpmsReset_Sts: 0=Cx0_Default_value_ (Default value(无显示需求)), 1=Cx1_Reset_On_going_ (Reset On-going(正在进行复位)), 2=Cx2_Reset_Finished_ (Reset Finished(复位成功)), 3=Cx3_Reset_Failed_ (Reset Failed(复位错误))
  compu method CM_IPB_ItpmsSys_Sts: 0=Cx0_Normal, 1=Cx1_Fault
  compu method CM_IPB_PlungerPressure_Status: 0=Cx0_Valid_Init (Valid/Init), 1=Cx1_Invalid_Default (Invalid/Default)
  compu method CM_IPB_System_Status: 0=Cx0_BBF_FullSys_Init_Default (BBF FullSys/Init/Default), 1=Cx1_BBF_DegradedPedalFeel (BBF DegradedPedalFeel), 2=Cx2_BBF_CircuitSperation (BBF CircuitSperation), 3=Cx3_BBF_C1_2BoostOnly (BBF C1/2BoostOnly), 4=Cx4_HydBack_w_act_HydBack_w_o_act (HydBack w/act/HydBack w/o act), 5=Cx5_Reserved, 6=Cx6_Reserved, 7=Cx7_Reserved
  compu method CM_IPB_vehicleSpeedValid: 0=Cx0_Valid, 1=Cx1_Not_valid (Not valid)
  compu method CM_IPB_WheelOdoPulse_FL: identical
  compu method CM_IPB_WheelOdoPulse_FL_Valid: 0=Cx0_Valid, 1=Cx1_Not_valid (Not valid)
  compu method CM_IPB_WheelOdoPulse_FR: identical
  compu method CM_IPB_WheelOdoPulse_FR_Valid: 0=Cx0_Valid, 1=Cx1_Not_valid (Not valid)
  compu method CM_IPB_WheelOdoPulse_RL: identical
  compu method CM_IPB_WheelOdoPulse_RL_Valid: 0=Cx0_Valid, 1=Cx1_Not_valid (Not valid)
  compu method CM_IPB_WheelOdoPulse_RR: identical
  compu method CM_IPB_WheelOdoPulse_RR_Valid: 0=Cx0_Valid, 1=Cx1_Not_valid (Not valid)
  compu method CM_IPB_wheelSpeedFLValid: 0=Cx0_Valid, 1=Cx1_Not_valid (Not valid)
  compu method CM_IPB_wheelSpeedFRValid: 0=Cx0_Valid, 1=Cx1_Not_valid (Not valid)
  compu method CM_IPB_wheelSpeedRLValid: 0=Cx0_Valid, 1=Cx1_Not_valid (Not valid)
  compu method CM_IPB_wheelSpeedRRValid: 0=Cx0_Valid, 1=Cx1_Not_valid (Not valid)
  compu method CM_IVI_AC_SW_Req: 0=Cx0_No_Request (No Request), 1=Cx1_ON, 2=Cx2_OFF, 3=Cx3_INVALID
  compu method CM_IVI_ACMode_Set: 0=Cx0_No_Request (No Request), 1=Cx1_ (舒适), 2=Cx2_ (经济), 3=Cx3_INVALID
  compu method CM_IVI_Air_Vol_Set: 0=Cx0_No_Request (No Request), 1=Cx1_Gear_1 (Gear 1), 2=Cx2_Gear_2 (Gear 2), 3=Cx3_Gear_3 (Gear 3), 4=Cx4_Gear_4 (Gear 4), 5=Cx5_Gear_5 (Gear 5), 6=Cx6_Gear_6 (Gear 6), 7=Cx7_Gear_7 (Gear 7), 8=Cx8_Reversed, 9=Cx9_Reversed, 10=CxA_Reversed, 11=CxB_Reversed, 12=CxC_Reversed, 13=CxD_Reversed, 14=CxE_Reversed, 15=CxF_INVALID
  compu method CM_IVI_AUTO_SW_Req: 0=Cx0_No_Request (No Request), 1=Cx1_ON, 2=Cx2_OFF, 3=Cx3_INVALID
  compu method CM_IVI_AVHOnOffSet: 0=Cx0_No_Request (No Request), 1=Cx1_ON, 2=Cx2_OFF, 3=Cx3_INVALID
  compu method CM_IVI_BT_Phone_Sts: 0=Cx0_No_Request (No Request), 1=Cx1_Oe_ (通话中), 2=Cx2_ (未通话), 3=Cx3_INVALID
  compu method CM_IVI_BTHFP_AutoAirVOL_SW: 0=Cx0_No_Request (No Request), 1=Cx1_ON, 2=Cx2_OFF, 3=Cx3_INVALID
  compu method CM_IVI_CrawlingModeReq: 0=Cx0_No_Request (No Request), 1=Cx1_ON, 2=Cx2_OFF, 3=Cx3_INVALID
  compu method CM_IVI_CSTOnOffSet: 0=Cx0_No_Request (No Request), 1=Cx1_ON, 2=Cx2_OFF, 3=Cx3_INVALID
  compu method CM_IVI_Cur_FlashSts_C: 0=Cx0_ (未刷写), 1=Cx1_ss_ (刷写高压件), 2=Cx2_ss_ (非高压件), 3=Cx3_IVI (刷写IVI)
  compu method CM_IVI_DrvModset_Req: 0=Cx0_No_Request (No Request), 1=Cx1_Ae_ (标准模式), 2=Cx2_Ae_ (省电模式), 3=Cx3_Ae_ (超级省电模式), 4=Cx4_Reserved, 5=Cx5_Reserved, 6=Cx6_Reserved, 7=Cx7_Reserved
  compu method CM_IVI_ECCIntExtCirc_Req: 0=Cx0_No_Request (No Request), 1=Cx1_Ae_ (内循环), 2=Cx2_ (外循环), 3=Cx3_INVALID
  compu method CM_IVI_Energy_RE_Set: 0=Cx0_No_Request (No Request), 1=Cx1_ (低档), 2=Cx2_Oe_Reserved_ (中档(Reserved)), 3=Cx3_ss_ (高档)
  compu method CM_IVI_EPS_Modset_Req: 0=Cx0_No_Request (No Request), 1=Cx1_Ae_ (舒适模式), 2=Cx2_Ae_ (标准模式), 3=Cx3_Reserved, 4=Cx4_Reserved, 5=Cx5_Reserved, 6=Cx6_Reserved, 7=Cx7_Reserved
  compu method CM_IVI_ESPOffSw: 0=Cx0_No_Request (No Request), 1=Cx1_OFF, 2=Cx2_ON, 3=Cx3_INVALID
  compu method CM_IVI_FastCoolingReq: 0=Cx0_No_Request (No Request), 1=Cx1_ON, 2=Cx2_OFF, 3=Cx3_INVALID
  compu method CM_IVI_FrntDefrst_SW_Req: 0=Cx0_No_Request (No Request), 1=Cx1_ON, 2=Cx2_OFF, 3=Cx3_INVALID
  compu method CM_IVI_HDCOnOffSet: 0=Cx0_No_Request (No Request), 1=Cx1_ON, 2=Cx2_OFF, 3=Cx3_INVALID
  compu method CM_IVI_hvacFrModeReq: 0=Cx0_No_Request (No Request), 1=Cx1_Face, 2=Cx2_Face_and_Foot (Face and Foot), 3=Cx3_Foot, 4=Cx4_Foot_and_defrost (Foot and defrost), 5=Cx5_Window, 6=Cx6_Reversed, 7=Cx7_Reversed
  compu method CM_IVI_IntelligenTaerationReq: 0=Cx0_No_Request (No Request), 1=Cx1_ON, 2=Cx2_OFF, 3=Cx3_INVALID
  compu method CM_IVI_ItpmsReset_Set: 0=Cx0_No_Request (No Request), 1=Cx1_Request
  compu method CM_IVI_OTA_ReqKL15PowerOn_C: 0=Cx0_No_request (No request), 1=Cx1_OTA_ (OTA上电请求), 2=Cx2_OTA_ (OTA下电请求), 3=Cx3_Reserved
  compu method CM_IVI_OTAMODE_C: 0=Cx0_Normal, 1=Cx1_OTAAe_ (OTA模式), 2=Cx2_OTAAe_ (非OTA模式), 3=Cx3_Reserved
  compu method CM_IVI_Power_SW_Req: 0=Cx0_No_Request (No Request), 1=Cx1_ON, 2=Cx2_OFF, 3=Cx3_INVALID
  compu method CM_IVI_SetACTemp: 0=Cx00_No_Request (No Request), 1=Cx01_17_ (17℃), 2=Cx02_18_ (18℃), 3=Cx03_19_ (19℃), 4=Cx04_20_ (20℃), 5=Cx05_21_ (21℃), 6=Cx06_22_ (22℃), 7=Cx07_23_ (23℃), 8=Cx08_24_ (24℃), 9=Cx09_25_ (25℃), 10=Cx0A_26_ (26℃), 11=Cx0B_27_ (27℃), 12=Cx0C_28_ (28℃), 13=Cx0D_29_ (29℃), 14=Cx0E_30_ (30℃), 15=Cx0F_31_ (31℃), 16=Cx10_32_ (32℃), 17=Cx11_33_ (33℃), 18=Cx12_Reserved, 19=Cx13_Reserved, 20=Cx14_Reserved, 21=Cx15_Reserved, 22=Cx16_Reserved, 23=Cx17_Reserved, 24=Cx18_Reserved, 25=Cx19_Reserved, 26=Cx1A_Reserved, 27=Cx1B_Reserved, 28=Cx1C_Reserved, 29=Cx1D_Reserved, 30=Cx1E_Reserved, 31=Cx1F_Reserved
  compu method CM_IVI_Time_Day: identical
  compu method CM_IVI_Time_Hour: identical
  compu method CM_IVI_Time_Min: identical
  compu method CM_IVI_Time_Month: identical
  compu method CM_IVI_Time_Sec: identical
  compu method CM_IVI_Time_Year: phys=raw+2000 for raw 0..255
  compu method CM_MCU_AllowInputTrq_Min: identical
  compu method CM_MCU_BATVOLT_ABNO: 0=Cx0_Normal, 1=Cx1_Fault
  compu method CM_MCU_bus_Volt: identical
  compu method CM_MCU_CAL_SW_VER: identical
  compu method CM_MCU_CAL_VERS: identical
  compu method CM_MCU_ComLostFlt_VCU: 0=Cx0_Normal, 1=Cx1_Fault
  compu method CM_MCU_CPLD_RUNFLT: 0=Cx0_Normal, 1=Cx1_Fault
  compu method CM_MCU_CrashErr_FAULT: 0=Cx0_Normal, 1=Cx1_Fault
  compu method CM_MCU_CrashSts: 0=Cx0_oe_ (未发生碰撞), 1=Cx1_oe_ (发生碰撞)
  compu method CM_MCU_EEPRROM_FAULT: 0=Cx0_Normal, 1=Cx1_Fault
  compu method CM_MCU_FltProcLvl: 0=Cx0_ (正常), 1=Cx1_1_ (1级故障), 2=Cx2_2_ (2级故障), 3=Cx3_3_ (3级故障)
  compu method CM_MCU_HALL_FLT: 0=Cx0_Normal, 1=Cx1_Fault
  compu method CM_MCU_HeatSink_TEMPOVER: 0=Cx0_Normal, 1=Cx1_Fault
  compu method CM_MCU_HeatSinkTEMPOVER_LimtToqFLG: 0=Cx0_Normal, 1=Cx1_Fault
  compu method CM_MCU_HW_CURT_HIGH: 0=Cx0_Normal, 1=Cx1_Fault
  compu method CM_MCU_HW_CURT_SERIOUS_HIGH: 0=Cx0_Normal, 1=Cx1_Fault
  compu method CM_MCU_HW_VERS: identical
  compu method CM_MCU_HW_VOLT_HIGH: 0=Cx0_Normal, 1=Cx1_Fault
  compu method CM_MCU_HW_VOLT_SERIOUS_HIGH: 0=Cx0_Normal, 1=Cx1_Fault
  compu method CM_MCU_IGBT_TEMP: phys=raw-45 for raw 0..255
  compu method CM_MCU_IGBT_TEMP_OVER: 0=Cx0_Normal, 1=Cx1_Fault
  compu method CM_MCU_IGBT_TEMP_OVER_LimtToqFLG: 0=Cx0_Normal, 1=Cx1_Fault
  compu method CM_MCU_IGBT_TJ_OVER_LimtToqFLG: 0=Cx0_Normal, 1=Cx1_Fault
  compu method CM_MCU_LOWRBRDG_FLT: 0=Cx0_Normal, 1=Cx1_Fault
  compu method CM_MCU_LOWRBRDG_SERIOUS_FLT: 0=Cx0_Normal, 1=Cx1_Fault
  compu method CM_MCU_MCU_F_SUM: identical
  compu method CM_MCU_MCU_SUPPLIER: identical
  compu method CM_MCU_MOT_CODE1: identical
  compu method CM_MCU_MOT_TEMP: phys=raw-45 for raw 0..255
  compu method CM_MCU_Motor_NUM: identical
  compu method CM_MCU_Motor_SUM: identical
  compu method CM_MCU_MOTOR_TEMP_OVER: 0=Cx0_Normal, 1=Cx1_Fault
  compu method CM_MCU_MOTOR_TEMPOVER_LimtToqFLG: 0=Cx0_Normal, 1=Cx1_Fault
  compu method CM_MCU_MOTOverTEMPLamp: 0=Cx0_ (熄灭), 1=Cx1_ (点亮)
  compu method CM_MCU_OVER_SPD_LimtToq: 0=Cx0_Normal, 1=Cx1_Fault
  compu method CM_MCU_PART_VERS: identical
  compu method CM_MCU_PhaseLose_FLT: 0=Cx0_Normal, 1=Cx1_Fault
  compu method CM_MCU_Rotary_FLT: 0=Cx0_Normal, 1=Cx1_Fault
  compu method CM_MCU_SERIOUSOVER_SPD: 0=Cx0_Normal, 1=Cx1_Fault
  compu method CM_MCU_SW_CURT_HIGH: 0=Cx0_Normal, 1=Cx1_Fault
  compu method CM_MCU_SW_CURT_SERIOUS_HIGH: 0=Cx0_Normal, 1=Cx1_Fault
  compu method CM_MCU_SW_VERS: identical
  compu method CM_MCU_SW_VOLT_HIGH: 0=Cx0_Normal, 1=Cx1_Fault
  compu method CM_MCU_SW_VOLT_LOW: 0=Cx0_Normal, 1=Cx1_Fault
  compu method CM_MCU_SW_VOLT_SERIOUS_LOW: 0=Cx0_Normal, 1=Cx1_Fault
  compu method CM_MCU_Sys_Sts: 0=Cx0_ (驱动), 1=Cx1_ (发电)
  compu method CM_MCU_ToqCMD_FLT: 0=Cx0_Normal, 1=Cx1_Fault
  compu method CM_MCU_UPPRBRDG_FLT: 0=Cx0_Normal, 1=Cx1_Fault
  compu method CM_MCU_UPPRBRDG_SERIOUS_FLT: 0=Cx0_Normal, 1=Cx1_Fault
  compu method CM_MCU_VOLT_HIGH_LimtToq: 0=Cx0_Normal, 1=Cx1_Fault
  compu method CM_MCU_VOLT_LOW_LimtToq: 0=Cx0_Normal, 1=Cx1_Fault
  compu method CM_MCU_WorkMode: 0=Cx0_ (初始化), 1=Cx1_ (低压待机), 2=Cx2_ss_ (高压待机), 3=Cx3_Ae_ (扭矩模式), 4=Cx4_Ae_ (加热模式), 5=Cx5_Oe_ (主动放电), 6=Cx6_ (故障状态), 7=Cx7_ss_ (待休眠状态), 8=Cx8_ss_ (休眠状态), 9=Cx9_Reserved, 10=CxA_Reserved, 11=CxB_Reserved, 12=CxC_Reserved, 13=CxD_Reserved, 14=CxE_Reserved, 15=CxF_Reserved
  compu method CM_NMUd_IVI_16bit: identical
  compu method CM_NMUd_IVI_32bit: identical
  compu method CM_RollingCounte0x313: identical
  compu method CM_RollingCounter_110: identical
  compu method CM_RollingCounter_132: identical
  compu method CM_RollingCounter_1E3: identical
  compu method CM_RollingCounter_300: identical
  compu method CM_RollingCounter_303: identical
  compu method CM_RollingCounter_3A0: identical
  compu method CM_RollingCounter_90: identical
  compu method CM_RollingCounter_94: identical
  compu method CM_RollingCounter_98: identical
  compu method CM_RollingCounter0x162: identical
  compu method CM_RollingCounter0x182: identical
  compu method CM_RollingCounter0x192: identical
  compu method CM_RollingCounter0x201: identical
  compu method CM_RollingCounter0x310: identical
  compu method CM_RollingCounter0x92: identical
  compu method CM_RollingCounter152: identical
  compu method CM_RollingCounter30B: identical
  compu method CM_RollingCounter30F: identical
  compu method CM_TAS_SAS_SteeringAngleVld: 0=Cx0_Initializing, 1=Cx1_Valid, 2=Cx2_Invalid, 3=Cx3_Reserved
  compu method CM_VCU_AccPedalPosition: identical
  compu method CM_VCU_AccPedalPositionFltSts: 0=Cx0_Normal, 1=Cx1_Fault
  compu method CM_VCU_BatteryInletTempReq: phys=raw-45 for raw 0..255
  compu method CM_VCU_BattInlTDmd: phys=raw-48 for raw 0..255
  compu method CM_VCU_BattThemlMngDmd: 0=Cx0_ (无需求), 1=Cx1_ (加热一档需求), 2=Cx2_ (加热二挡需求), 3=Cx3_ (加热三挡需求), 4=Cx4_Oe_ae_ (制冷一档需求), 5=Cx5_Oe_ae_ (制冷二挡需求), 6=Cx6_Oe_ae_ (制冷三挡需求), 7=Cx7_Ae_ (内循环), 8=Cx8_Reserved, 9=Cx9_Reserved, 10=CxA_Reserved, 11=CxB_Reserved, 12=CxC_Reserved, 13=CxD_Reserved, 14=CxE_Reserved, 15=CxF_Reserved
  compu method CM_VCU_BrkPedalFltSts: 0=Cx0_Normal, 1=Cx1_Fault
  compu method CM_VCU_BrkPedalSts: 0=Cx0_ (未踩下), 1=Cx1_ (踩下)
  compu method CM_VCU_CalVersS: identical
  compu method CM_VCU_ConnectGunLamp: 0=Cx0_ (熄灭), 1=Cx1_ (点亮)
  compu method CM_VCU_Control_MCUCmd: 0=Cx0_ (待机), 1=Cx1_Ae_ (转矩模式), 2=Cx2_Ae_ (加热模式), 3=Cx3_Ae_ (转速模式(预留)), 4=Cx4_Oe_ (主动放电), 5=Cx5_ss (休眠), 6=Cx6_ (停机), 7=Cx7_Reserved
  compu method CM_VCU_CrawlingSts: 0=Cx0_ (关闭), 1=Cx1_ (开启)
  compu method CM_VCU_DCCHARGE_FaultSts: 0=Cx0_ae_ (未充电), 1=Cx1_ae_Oe_ (充电准备中), 2=Cx2_ae_Oe_ (充电中), 3=Cx3_ae_ (充电完成), 4=Cx4_ae_Oe_Oe_ (充电中止-车端故障), 5=Cx5_ae_Oe_Oe_ae_ (充电中止-充电柜故障), 6=Cx6_Reserved, 7=Cx7_Reserved
  compu method CM_VCU_DCCHARGE_Sts: 0=Cx0_Ae_Oe_ (默认值), 1=Cx1_ae_ (插枪未充电), 2=Cx2_ae_Oe_ (充电准备中), 3=Cx3_ae_ (充电开始), 4=Cx4_ae_ (充电结束), 5=Cx5_Reserved, 6=Cx6_Reserved, 7=Cx7_Reserved
  compu method CM_VCU_DCChrgSoktT1: phys=raw-45 for raw 0..255
  compu method CM_VCU_DCChrgSoktT2: phys=raw-45 for raw 0..255
  compu method CM_VCU_DCNegRlyCtrlCmd: 0=Cx0_ (断开), 1=Cx1_ue_ (吸合)
  compu method CM_VCU_DCPosRlyCtrlCmd: 0=Cx0_ (断开), 1=Cx1_ue_ (吸合)
  compu method CM_VCU_DCRlyAdhFlt: 0=Cx0_ (正常), 1=Cx1_ (正极接触器烧结), 2=Cx2_ (负极接触器烧结), 3=Cx3_ (正极与负极同时烧结)
  compu method CM_VCU_DriveMode: 0=Cx0_Invalid, 1=Cx1_Ae_ (标准模式), 2=Cx2_Ae_ (省电模式), 3=Cx3_Ae_ (超级省电模式)
  compu method CM_VCU_DrvgMilg: identical
  compu method CM_VCU_DrvgMilg_Valid: 0=Cx0_INVALID, 1=Cx1_VALID
  compu method CM_VCU_Emergent_HVPOWERDOWN_REQ: 0=Cx0_ (不处理), 1=Cx1_ (下电)
  compu method CM_VCU_EnergyFedBak_Class: 0=Cx0_Invalid, 1=Cx1_ (低档), 2=Cx2_Oe_Reserved_ (中档(Reserved)), 3=Cx3_ss_ (高档)
  compu method CM_VCU_FaultLevel: 0=Cx0_level_0 (level 0), 1=Cx1_level_1 (level 1), 2=Cx2_level_2 (level 2), 3=Cx3_level_3 (level 3)
  compu method CM_VCU_GearSig: 0=Cx0_Invalid, 1=Cx1_P_ (P档), 2=Cx2_R_ (R档), 3=Cx3_N_ (N档), 4=Cx4_D_ (D档), 5=Cx5_Reserved, 6=Cx6_Reserved, 7=Cx7_Reserved
  compu method CM_VCU_HLVHradWireFlt: 0=Cx0_ (正常), 1=Cx1_ (故障)
  compu method CM_VCU_HVPOWERDWUP_REQ: 0=Cx0_Invalid, 1=Cx1_ss_ (高压上电请求), 2=Cx2_ss_ (高压下电请求), 3=Cx3_Reserved
  compu method CM_VCU_HwVers: identical
  compu method CM_VCU_LimpHomeLamp: 0=Cx0_ (熄灭), 1=Cx1_ (点亮)
  compu method CM_VCU_MOT_TOR_CMD_Valid: 0=Cx0_ (有效), 1=Cx1_ (无效)
  compu method CM_VCU_MotStartCmd: 0=Cx0_ (关闭), 1=Cx1_ (开启)
  compu method CM_VCU_PartVers: identical
  compu method CM_VCU_PowerSysFlt_Warning: 0=Cx0_ (正常), 1=Cx1_ (动力系统故障)
  compu method CM_VCU_PumpFltSts: 0=Cx0_Normal, 1=Cx1_Fault
  compu method CM_VCU_RdyLamp: 0=Cx0_ (熄灭), 1=Cx1_ (点亮)
  compu method CM_VCU_SwVers: identical
  compu method CM_VCU_SwVersM: identical
  compu method CM_VCU_SysFlautClass: 0=Cx0_ (无故障), 1=Cx1_1_ (1级故障), 2=Cx2_2_ (2级故障), 3=Cx3_3_ (3级故障)
  compu method CM_VCU_VehEnergy_Dis: 0=Cx0_ (有效), 1=Cx1_ (不显示), 2=Cx2_ (纯电动驱动), 3=Cx3_ (纯电动回馈), 4=Cx4_Reserved, 5=Cx5_Reserved, 6=Cx6_Reserved, 7=Cx7_Reserved
  compu method CM_VCU_WaterPumpDutyCycle: identical
  compu method CM_VCU_WaterPumpSts: 0=Cx0_Normal, 1=Cx1_Fault
  compu method CM_CrcSig_Pack_{0..2}: identical
  compu method CM_Led{1..4}_Control: 0=Cx0_LED_ON, 1=Cx1_LED_OFF
  compu method CM_PowerMode: 0=Cx0_OFF, 1=Cx1_ON, 2=Cx2_Reserve
  compu method CM_Sig_0x114_Used_{1..5}: identical
  compu method CM_Sig_0x402_Used_{1..5}: identical
  compu method CM_Sig_0x403_Used_{1..5}: identical
  compu method CM_SupA_Checksum_0x112: identical
  compu method CM_SupA_Counter_0x112: identical
  compu method CM_SupB_Checksum_0x400: identical
  compu method CM_SupB_Counter_0x400: identical
  compu method CM_System_Run_Time: phys=raw*0.5-10 for raw 0..40; unit o
  compu method CM_AAA_Angle: phys=raw*0.5-10 for raw 0..40; unit o
  compu method CM_Sig_0x114_Used_6: identical
  compu method CM_E_Sig_0x302_Used_{1..3}: identical
  compu method CM_F_AAA_Angle: phys=raw*0.5-10 for raw 0..40; unit o
  compu method CM_F_Button{1..4}_State: 0=Cx0_Button_Push, 1=Cx1_Button_Release, 2=Cx2_Reserve
  compu method CM_F_Meg_E2E_Error: 0=Cx00_No_E2E_Error (No E2E Error), 1=Cx01_Message_0x301_E2E_Error (Message 0x301 E2E Error), 2=Cx02_Message_0x304_E2E_Error (Message 0x304 E2E Error)
  compu method CM_F_Mes_Lost_Error: 0=Cx00_No_Message_Lost (No Message Lost), 1=Cx01_Message_0x300_Lost (Message 0x300 Lost), 2=Cx02_Message_0x301_Lost (Message 0x301 Lost), 3=Cx03_Message_0x302_Lost (Message 0x302 Lost), 4=Cx04_Message_0x303_Lost (Message 0x303 Lost), 5=Cx05_Message_0x304_Lost (Message 0x304 Lost)
  compu method CM_F_PowerMode: 0=Cx0_OFF, 1=Cx1_ON, 2=Cx2_Reserve
  compu method CM_F_Sig_0x214_Used_{1..3}: identical
  compu method CM_F_Sig_0x214_Used_5: identical
  compu method CM_SupD_Checksum_0x300: identical
  compu method CM_SupD_Checksum_0x304: identical
  compu method CM_SupD_Counter_0x300: identical
  compu method CM_SupD_Counter_0x304: identical
  compu method CM_SupF_Checksum_0x212: identical
  compu method CM_SupF_Counter_0x212: identical
package /DataType/Unit
  unit U_o: display-name=o, factor-si-to-unit=1, offset-si-to-unit=0
package /DataTypes
  109 x impl type:
    SG_Sig_Grp_0x110: category=STRUCTURE
      4 x element, all with category=TYPE_REFERENCE, range raw 0..1:
        Led{1..4}_State: implementation-data-type=Led{1..4}_State
    Led{1..4}_State: category=VALUE, base-type=boolean, compu {0=Cx0_LED_ON, 1=Cx1_LED_OFF}
    SG_Sig_Grp_0x111: category=STRUCTURE
      4 x element, all with category=TYPE_REFERENCE, range raw 0..1:
        Button{1..4}_State: implementation-data-type=Button{1..4}_State
    Button{1..4}_State: category=VALUE, base-type=boolean, compu {0=Cx0_Button_Push, 1=Cx1_Button_Release}
    SG_Sig_Grp_0x112: category=STRUCTURE
      element PowerMode: range raw 0..7, implementation-data-type=PowerMode
      element SupA_Checksum_0x112: range raw 0..255, implementation-data-type=SupA_Checksum_0x112
      element SupA_Counter_0x112: range raw 0..14, implementation-data-type=SupA_Counter_0x112
    PowerMode: category=VALUE, base-type=uint8
    SupA_Checksum_0x112: category=VALUE, base-type=uint8
    SupA_Counter_0x112: category=VALUE, base-type=uint8
    SG_Sig_Grp_0x113: category=STRUCTURE
      element AAA_Angle: range raw 0..63, implementation-data-type=AAA_Angle
    System_Run_Time: category=VALUE, base-type=uint8
    SG_Sig_Grp_0x400: category=STRUCTURE
      9 x element, all with category=TYPE_REFERENCE:
        CrcSig_Pack_0: range raw 0..1, implementation-data-type=CrcSig_Pack_3
        CrcSig_Pack_1: range raw 0..1, implementation-data-type=CrcSig_Pack_4
        CrcSig_Pack_2: range raw 0..1, implementation-data-type=CrcSig_Pack_5
        Led{1..4}_Control: range raw 0..1, implementation-data-type=Led{1..4}_Control_1
        SupB_Checksum_0x400: range raw 0..255, implementation-data-type=SupB_Checksum_0x400_1
        SupB_Counter_0x400: range raw 0..14, implementation-data-type=SupB_Counter_0x400_1
    CrcSig_Pack_0: category=VALUE, base-type=uint8
    CrcSig_Pack_1: category=VALUE, base-type=uint32
    CrcSig_Pack_2: category=VALUE, base-type=uint32
    Led{1..4}_Control: category=VALUE, base-type=boolean
    SupB_Checksum_0x400: category=VALUE, base-type=uint8
    SupB_Counter_0x400: category=VALUE, base-type=uint8
    CrcSig_Pack_3: category=VALUE, base-type=uint8
    CrcSig_Pack_4: category=VALUE, base-type=uint32
    CrcSig_Pack_5: category=VALUE, base-type=uint32
    Led{1..4}_Control_1: category=VALUE, base-type=boolean
    SupB_Checksum_0x400_1: category=VALUE, base-type=uint8
    SupB_Counter_0x400_1: category=VALUE, base-type=uint8
    SG_Sig_Grp_0x401: category=STRUCTURE
      4 x element, all with category=TYPE_REFERENCE, range raw 0..1:
        Button{1..4}_Control: implementation-data-type=Button{1..4}_Control
    Button{1..4}_Control: category=VALUE, base-type=boolean, compu {0=Cx0_Button_Enable, 1=Cx1_Button_Disable}
    SG_Sig_Grp_0x402: category=STRUCTURE
      5 x element, all with category=TYPE_REFERENCE:
        Sig_0x402_Used_1: range raw 0..15, implementation-data-type=Sig_0x402_Used_1
        Sig_0x402_Used_2: range raw 0..4095, implementation-data-type=Sig_0x402_Used_2
        Sig_0x402_Used_{3..5}: range raw 0..65535, implementation-data-type=Sig_0x402_Used_{3..5}
    Sig_0x402_Used_1: category=VALUE, base-type=uint8
    Sig_0x402_Used_{2..5}: category=VALUE, base-type=uint16
    SG_Sig_Grp_0x403: category=STRUCTURE
      5 x element, all with category=TYPE_REFERENCE:
        Sig_0x403_Used_1: range raw 0..15, implementation-data-type=Sig_0x403_Used_1
        Sig_0x403_Used_2: range raw 0..4095, implementation-data-type=Sig_0x403_Used_2
        Sig_0x403_Used_{3..5}: range raw 0..65535, implementation-data-type=Sig_0x403_Used_{3..5}
    Sig_0x403_Used_1: category=VALUE, base-type=uint8
    Sig_0x403_Used_{2..5}: category=VALUE, base-type=uint16
    AAA_Angle: category=VALUE, base-type=uint8
    ComM_Mode: category=STRUCTURE, sw-calibration-access=READ-ONLY, type-emitter=RTE
      element ComM_FULL_COM: implementation-data-type=uint8
    SG_Sig_Grp_0x114: category=STRUCTURE
      6 x element, all with category=TYPE_REFERENCE:
        Sig_0x114_Used_1: range raw 0..15, implementation-data-type=Sig_0x114_Used_1
        Sig_0x114_Used_2: range raw 0..4095, implementation-data-type=Sig_0x114_Used_2
        Sig_0x114_Used_3: range raw 0..65535, implementation-data-type=Sig_0x114_Used_3
        Sig_0x114_Used_4: range raw 0..65535, implementation-data-type=Sig_0x114_Used_4
        Sig_0x114_Used_5: range raw 0..255, implementation-data-type=Sig_0x114_Used_5
        Sig_0x114_Used_6: range raw 0..255, implementation-data-type=Sig_0x114_Used_6
    Sig_0x114_Used_1: category=VALUE, base-type=uint8
    Sig_0x114_Used_{2..4}: category=VALUE, base-type=uint16
    Sig_0x114_Used_5: category=VALUE, base-type=uint8
    Sig_0x114_Used_6: category=VALUE, base-type=uint8
    SG_Sig_Grp_0x210: category=STRUCTURE
      4 x element, all with category=TYPE_REFERENCE, range raw 0..3:
        F_Led{1..4}_State: implementation-data-type=F_Led{1..4}_State
    F_Led{1..4}_State: category=VALUE, base-type=uint8, compu {0=Cx0_LED_ON, 1=Cx1_LED_OFF, 2=Cx2_Reserve, 3=Cx3_Reserve}
    SG_Sig_Grp_0x211: category=STRUCTURE
      4 x element, all with category=TYPE_REFERENCE, range raw 0..7:
        F_Button{1..4}_State: implementation-data-type=F_Button{1..4}_State
    F_Button{1..4}_State: category=VALUE, base-type=uint8
    SG_Sig_Grp_0x212: category=STRUCTURE
      element F_PowerMode: range raw 0..7, implementation-data-type=F_PowerMode
      element SupF_Checksum_0x212: range raw 0..255, implementation-data-type=SupF_Checksum_0x212
      element SupF_Counter_0x212: range raw 0..14, implementation-data-type=SupF_Counter_0x212
    F_PowerMode: category=VALUE, base-type=uint8
    SupF_Checksum_0x212: category=VALUE, base-type=uint8
    SupF_Counter_0x212: category=VALUE, base-type=uint8
    SG_Sig_Grp_0x213: category=STRUCTURE
      element F_AAA_Angle: implementation-data-type=F_AAA_Angle
    F_AAA_Angle: category=VALUE, base-type=uint8
    SG_Sig_Grp_0x214: category=STRUCTURE
      4 x element, all with category=TYPE_REFERENCE, range raw 0..65535:
        F_Sig_0x214_Used_{1..3}: implementation-data-type=F_Sig_0x214_Used_{1..3}
        F_Sig_0x214_Used_5: implementation-data-type=F_Sig_0x214_Used_5
    F_Sig_0x214_Used_{1..3}: category=VALUE, base-type=uint16
    F_Sig_0x214_Used_5: category=VALUE, base-type=uint16
    SG_Sig_Grp_0x216: category=STRUCTURE
      element F_Meg_E2E_Error: range raw 0..255, implementation-data-type=F_Meg_E2E_Error
      element F_Mes_Lost_Error: range raw 0..255, implementation-data-type=F_Mes_Lost_Error
    F_Meg_E2E_Error: category=VALUE, base-type=uint8
    F_Mes_Lost_Error: category=VALUE, base-type=uint8
    SG_Sig_Grp_0x300: category=STRUCTURE
      6 x element, all with category=TYPE_REFERENCE:
        D_Led{1..4}_Control: range raw 0..3, implementation-data-type=D_Led{1..4}_Control
        SupD_Checksum_0x300: range raw 0..255, implementation-data-type=SupD_Checksum_0x300
        SupD_Counter_0x300: range raw 0..14, implementation-data-type=SupD_Counter_0x300
    D_Led{1..4}_Control: category=VALUE, base-type=uint8, compu {0=Cx0_Init, 1=Cx1_LED_ON, 2=Cx2_LED_OFF, 3=Cx3_Reserve}
    SupD_Checksum_0x300: category=VALUE, base-type=uint8
    SupD_Counter_0x300: category=VALUE, base-type=uint8
    SG_Sig_Grp_0x301: category=STRUCTURE
      4 x element, all with category=TYPE_REFERENCE, range raw 0..3:
        D_Button{1..4}_Control: implementation-data-type=D_Button{1..4}_Control
    D_Button{1..4}_Control: category=VALUE, base-type=uint8, compu {0=Cx0_Button_Mode1, 1=Cx1_Button_Mode2, 2=Cx2_Button_Disable}
    SG_Sig_Grp_0x302: category=STRUCTURE
      element E_Sig_0x302_Used_1: range raw 0..65535, implementation-data-type=E_Sig_0x302_Used_1
      element E_Sig_0x302_Used_2: range raw 0..255, implementation-data-type=E_Sig_0x302_Used_2
      element E_Sig_0x302_Used_3: range raw 0..255, implementation-data-type=E_Sig_0x302_Used_3
    E_Sig_0x302_Used_1: category=VALUE, base-type=uint16
    E_Sig_0x302_Used_2: category=VALUE, base-type=uint8
    E_Sig_0x302_Used_3: category=VALUE, base-type=uint8
    SG_Sig_Grp_0x304: category=STRUCTURE
      6 x element, all with category=TYPE_REFERENCE:
        D_Led{1..4}_CtrlMode: range raw 0..15, implementation-data-type=D_Led{1..4}_CtrlMode
        SupD_Checksum_0x304: range raw 0..255, implementation-data-type=SupD_Checksum_0x304
        SupD_Counter_0x304: range raw 0..14, implementation-data-type=SupD_Counter_0x304
    D_Led{1..4}_CtrlMode: category=VALUE, base-type=uint8, compu {0=Cx0_Can_Control, 1=Cx1_Button_Control_Mode1, 2=Cx2_Button_Control_Mode2, 3=Cx3_Reserve} "Source signal range: [0,2]"
    SupD_Checksum_0x304: category=VALUE, base-type=uint8
    SupD_Counter_0x304: category=VALUE, base-type=uint8
    Meg_Trigger_Type: category=VALUE, base-type=boolean, sw-calibration-access=READ-ONLY, type-emitter=RTE
package /DataTypes/DataConstrs
  range uint_2_DataConstr: raw 0..3
  range bool_1_DataConstr: raw 0..1
  range System_Run_Time: raw 0..63
  range CrcSig_Pack_{0..2}: raw 0..1
  range Led{1..4}_Control: raw 0..1
  range SupB_Checksum_0x400: raw 0..255
  range SupB_Counter_0x400: raw 0..14
package /DataTypes/BaseTypes
  base type ComM_Mode: category=FIXED_LENGTH, base-type-size=2, base-type-encoding=VOID, native-declaration=void
